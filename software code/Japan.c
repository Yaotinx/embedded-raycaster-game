#include "../inc/Japan.h"
#include "../inc/ST7735.h"

// 8x8 1-bit Bitmaps (Small and fast)
const uint8_t ko8[]  = {0x3E, 0x02, 0x02, 0x02, 0x3E, 0x00, 0x00, 0x00}; // コ
const uint8_t n8[]   = {0xC0, 0x30, 0xCC, 0xCC, 0x78, 0x30, 0x00, 0x00}; // ン
const uint8_t ni8[]  = {0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00}; // ニ
const uint8_t chi8[] = {0x38, 0x7E, 0x20, 0x3E, 0xA0, 0xA0, 0x00, 0x00}; // チ
const uint8_t wa8[]  = {0x44, 0x44, 0x66, 0x81, 0x81, 0x00, 0x00, 0x00}; // ワ
const uint8_t he8[]  = {0x00, 0x08, 0x7E, 0x48, 0x44, 0x42, 0x00, 0x00}; // ヘ
const uint8_t ta8[]  = {0x3C, 0x40, 0x7E, 0x44, 0x44, 0x44, 0x00, 0x00}; // タ
const uint8_t ge8[]  = {0x44, 0x24, 0x7E, 0x12, 0x22, 0x42, 0x00, 0x00}; // ゲ
const uint8_t mu8[]  = {0x00, 0x7C, 0x10, 0x38, 0x54, 0x12, 0x00, 0x00}; // ム
const uint8_t su8[]  = {0x00, 0x7E, 0x08, 0x1C, 0x2A, 0x44, 0x00, 0x00}; // ス
const uint8_t cho8[] = {0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00}; // ー

// New glyphs
const uint8_t ra8[]  = {0x7E, 0x08, 0x08, 0x1C, 0x2A, 0x48, 0x00, 0x00}; // ラ
const uint8_t u8[]   = {0x08, 0x7E, 0x49, 0x49, 0x41, 0x3E, 0x00, 0x00}; // ウ
const uint8_t do8[]  = {0x3C, 0x52, 0x51, 0x7E, 0x51, 0x52, 0x04, 0x00}; // ド
const uint8_t o8[]   = {0x08, 0x7C, 0x2A, 0x2A, 0x2A, 0x7C, 0x00, 0x00}; // オ
const uint8_t ba8[]  = {0x3C, 0x42, 0x42, 0x7E, 0x42, 0x42, 0x04, 0x00}; // バ
const uint8_t ki8[]  = {0x10, 0x7E, 0x12, 0x32, 0x52, 0x10, 0x00, 0x00}; // キ
const uint8_t ru8[]  = {0x7C, 0x04, 0x04, 0x3C, 0x44, 0x3C, 0x00, 0x00}; // ル
const uint8_t ga8[]  = {0x44, 0x24, 0x7E, 0x16, 0x24, 0x44, 0x04, 0x00}; // ガ
const uint8_t re8[]  = {0x00, 0x7E, 0x20, 0x20, 0x3E, 0x20, 0x00, 0x00}; // レ

const uint8_t *JapanFont[] = {
    0,      // J_NULL = 0
    ko8,    // J_KO   = 1
    n8,     // J_N    = 2
    ni8,    // J_NI   = 3
    chi8,   // J_CHI  = 4
    wa8,    // J_WA   = 5
    he8,    // J_HE   = 6
    ta8,    // J_TA   = 7
    ge8,    // J_GE   = 8
    mu8,    // J_MU   = 9
    su8,    // J_SU   = 10
    cho8,   // J_CHO  = 11
    ra8,    // J_RA   = 12
    u8,     // J_U    = 13
    do8,    // J_DO   = 14
    o8,     // J_O    = 15
    ba8,    // J_BA   = 16
    ki8,    // J_KI   = 17
    ru8,    // J_RU   = 18
    ga8,    // J_GA   = 19
    re8,    // J_RE   = 20
};

static uint32_t JapanX, JapanY;

void Japan_SetCursor(uint32_t newX, uint32_t newY){
    if(newX > 127 || newY > 159) return;
    JapanX = newX;
    JapanY = newY;
}

void Japan_OutChar(Japan_t ch){
    if(ch == J_NULL) return;

    if((JapanX + 8) > 127){
        JapanX = 0;
        JapanY += 8;
    }

    const uint8_t *bitmap = JapanFont[ch];
    for(int y = 0; y < 8; y++){
        uint8_t row = bitmap[y];
        for(int x = 0; x < 8; x++){
            if(row & (0x80 >> x)){
                ST7735_DrawPixel(JapanX + x, JapanY + y, ST7735_WHITE);
            } else {
                ST7735_DrawPixel(JapanX + x, JapanY + y, ST7735_BLACK);
            }
        }
    }
    JapanX += 8;
}

void Japan_OutString(const Japan_t *ptr){
    while(*ptr != J_NULL){
        Japan_OutChar(*ptr);
        ptr++;
    }
}